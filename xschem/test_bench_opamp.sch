** sch_path: xschem/test_bench_opamp.sch
**.subckt test_bench_opamp
x1 OUT PLUS MINUS VCC VSS opamp_test
**** begin user architecture code


.option method=gear

.option wnflag=1

.param VCCGAUSS = agauss(1.8, 0.05, 1)
.param VCC = 'VCCGAUS'

.param TEMPGAUSS = agauss(40, 30, 1)
.option temp = 'TEMPGAUSS'

.include stimuli_test_bench_opamp.cir
.control
	option seed=9
	let run=0
	dowhile run <= 100
		save all
		tran 1n 4000n uic
		remzerovec
		write test_bench_opamp.raw
		set appendwrite
		reset
		let run = run + 1
	end
.endc


[
set sky130_corner(tt
**** end user architecture code
**.ends

* expanding   symbol:  /home/ttuser/tt_projects/tt10-analog-test-v00/xschem/opamp_test.sym # of
*+ pins=5
** sym_path: xschem/opamp_test.sym
** sch_path: xschem/opamp_test.sch
.subckt opamp_test OUT PLUS MINUS VCC VSS
*.ipin OUT
*.ipin PLUS
*.ipin MINUS
*.ipin VCC
*.ipin VSS
XR1 net3 VCC VSS sky130_fd_pr__res_xhigh_po_2p85 L=2.85 mult=1 m=1
XM1 net2 MINUS net1 VSS sky130_fd_pr__nfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 net1 net3 VSS VSS sky130_fd_pr__nfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM5 net3 net3 VSS VSS sky130_fd_pr__nfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM6 OUT PLUS net1 VSS sky130_fd_pr__nfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 OUT net2 VCC VDD sky130_fd_pr__pfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM4 net2 net2 VCC VDD sky130_fd_pr__pfet_01v8_lvt L=0.15 W=1 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
